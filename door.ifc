Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView]
File name: door.ifc
Time: 2026-09-09T00:00:00
Author: INVISIBLE DOORS
Organization: INVISIBLE DOORS
Written by: Showroom R15
Made in: Showroom R15

# IfcBuildingStorey, Finished floor
In: Building
Elevation: 0 m

# IfcDoor, Алюминиевая дверь Slim
In: Finished floor
Description: Coordination geometry; not a native wall-hosted family; OverallHeight: 2.048 m; OverallWidth: 0.876 m; PredefinedType: DOOR; OperationType: SINGLE_SWING_RIGHT
INVISIBLE_DOORS_Configuration - Manufacturer: INVISIBLE DOORS; Model: alyuminievaya-dver; Finish: Прозрачное; FinishOutside: Прозрачное; FinishInside: Общее стеклянное полотно; Opening: right-out; Source: https://invisible-doors.ru/public_files/recommendations.pdf; GeometryUse: interior visualisation and coordination; simplified frame and hardware; LeafWidthMm: 800; LeafHeightMm: 2000; LeafThicknessMm: 40
